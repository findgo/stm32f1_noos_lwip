# Keil uVision project stm32f1noos_lwip.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f1noos_lwip +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,DEBUG_MSG
  c misc: --gnu
  c include: ..\common;..\dirver;..\module;..\user;..\util;..\lib\lwip-1.4.1\;..\lib\lwip-1.4.1\src\include;..\lib\lwip-1.4.1\src\include\ipv4;..\lib\lwip-1.4.1\src\include\netif;..\lib\lwip-1.4.1\arch;..\lib\lwip-1.4.1\arch\netcard;..\dirver\usrnet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group driver
    ../dirver/: systick.c usart.c
    ../dirver/usrnet/: helloworld.c dns_parse.c
  group user
    ../user/: main.c stm32f10x_it.c
  group module
    ../module/: debug.c delay.c mclock.c Mserial.c mtimers.c
  group lwip-netif
    ../lib/lwip-1.4.1/src/netif/: ethernetif.c etharp.c
  group lwip-api
    ../lib/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-core
    ../lib/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lib/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip-arch
    ../lib/lwip-1.4.1/arch/: sys_arch.c
    ../lib/lwip-1.4.1/arch/netcard/: bsp_spi1.c enc28j60.c
    ../lib/lwip-1.4.1/: netconf.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
